# Repository jpowen898/DiscTransmitterPCBs

File ReadMe.txt:

This File has 3 difference PCB's in it

//DiscTransmitter.pro  -> Seven Segment Display Board
//DiscTransmitter/"Transmitter Board"/"Transmitter Board.pro"  ->   Transmit/Revieve Protype board
//DiscTransmitter/"Minimized Transmitter"/"Minimized Transmitter.pro"   ->   Transmit only board

## KiCad design Minimized Transmitter/Minimized Transmitter.kicad_pcb

Parts:
BT1: Battery_Cell; PRT-11892
C1: 0.1uF; C_0402_1005Metric
D1: LED; LED_1206_3216Metric
J1: Conn_01x03_Male; SlideSwitch_SMD_PN#COM-10860
J2: Conn_01x02_Male; 2_pad_sufacemount
J4: Conn_01x05_Male; SWD_5_Pin_Minimized_SurfaceMount
R1: R_Small; R_0402_1005Metric
R2: 100Kohms; R_0402_1005Metric
SW1: SW_Push; KMR221GLFS
U1: LPC824M201JHI33; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U2: RFM69HCW; RFM96HCW

Connections:
+3V3: J1.2, J4.1, R2.1, U1.19 (VDD), U2.2 (3.3V)
DIO0: U1.11 (PIO0_27), U2.13 (DIO0)
GND: BT1.2 (-), C1.1, D1.1 (K), J1.1, J2.1, J4.2, SW1.1, U1.33 (VSS), U2.3 (GND), U2.8 (GND)
LED: R1.2, U1.16 (PIO0_1)
MISO: U1.13 (PIO0_25), U2.14 (MISO)
MOSI: U1.12 (PIO0_26), U2.5 (MOSI)
NSS: U1.15 (PIO0_15), U2.7 (NSS)
unnamed: BT1.1 (+), J1.3
unnamed: D1.2 (A), R1.1
Reset: U1.10 (PIO0_16), U2.9 (RESET)
SCK: U1.14 (PIO0_24), U2.6 (SCK)
SWDCLK: J4.4, U1.6 (PIO0_3)
SWDIO: J4.3, U1.7 (PIO0_2)
TX: J2.2, U1.9 (PIO0_10)
nRESET: C1.2, J4.5, R2.2, SW1.2, U1.3 (PIO0_5)

Notes on the sheet:
Reset Button
Serial Out
LED
Battery
Radio
SWD Connections
Programable Button

Board: 2 copper layers, 27.1 x 27.1 mm, 11 parts (3 on the bottom side), 15 nets.

## KiCad design DiscTransmitter.kicad_pcb

Parts:
J1, J2, J4: Conn_01x01_Male; Socket_Strip_Straight_1x01_Pitch2.54mm
J3: Conn_01x04_Male; Socket_Strip_Straight_1x04_Pitch2.54mm
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: R_Small; R_0402
U1, U3, U4, U5: SNx4HC595_8b_Shift_Reg; 8B_Shift_Reg_SN74HC595B
U2: 4-DigitSevenSegment; TwoDigDisplayX2

Connections:
+5V: J3.2, U1.16 (VCC), U3.16 (VCC), U4.16 (VCC), U5.16 (VCC)
GND: J3.1, U1.8 (GND), U2.22 (GND~), U2.23 (GND~), U2.31 (GND~), U2.32 (GND), U3.8 (GND), U4.8 (GND), U5.8 (GND)
unnamed: J1.1, U1.13 (OE'), U3.13 (OE'), U4.13 (OE'), U5.13 (OE')
unnamed: J2.1, U1.10 (SRCLR'), U3.10 (SRCLR'), U4.10 (SRCLR'), U5.10 (SRCLR')
unnamed: J3.3, U5.14 (SER)
unnamed: J3.4, U1.11 (SRCLK), U3.11 (SRCLK), U4.11 (SRCLK), U5.11 (SRCLK)
unnamed: J4.1, U1.12 (RCLK), U3.12 (RCLK), U4.12 (RCLK), U5.12 (RCLK)
unnamed: R1.1, U5.5 (Qf)
unnamed: R1.2, U2.36 (F1)
unnamed: R2.1, U2.1 (E1)
unnamed: R2.2, U5.4 (Qe)
unnamed: R3.1, U5.6 (Qg)
unnamed: R3.2, U2.35 (G1)
unnamed: R4.1, U2.2 (D1)
unnamed: R4.2, U5.3 (Qd)
unnamed: R5.1, U5.15 (Qa)
unnamed: R5.2, U2.34 (A1)
unnamed: R6.1, U2.3 (C1)
unnamed: R6.2, U5.2 (Qc)
unnamed: R7.1, U5.1 (Qb)
unnamed: R7.2, U2.33 (B1)
unnamed: R8.1, U2.4 (DP)
unnamed: R8.2, U5.7 (Qh)
unnamed: R9.1, U2.5 (E2)
unnamed: R9.2, U4.4 (Qe)
unnamed: R10.1, U2.6 (D2)
unnamed: R10.2, U4.3 (Qd)
unnamed: R11.1, U4.5 (Qf)
unnamed: R11.2, U2.30 (F2)
unnamed: R12.1, U2.8 (C2)
unnamed: R12.2, U4.2 (Qc)
unnamed: R13.1, U4.15 (Qa)
unnamed: R13.2, U2.29 (A2)
unnamed: R14.1, U2.7 (G2)
unnamed: R14.2, U4.6 (Qg)
unnamed: R15.1, U4.1 (Qb)
unnamed: R15.2, U2.28 (B2)
unnamed: R16.1, U2.9 (DP2)
unnamed: R16.2, U4.7 (Qh)
unnamed: R17.1, U3.5 (Qf)
unnamed: R17.2, U2.27 (F3)
unnamed: R18.1, U2.10 (E3)
unnamed: R18.2, U3.4 (Qe)
unnamed: R19.1, U3.6 (Qg)
unnamed: R19.2, U2.26 (G3)
unnamed: R20.1, U2.11 (D3)
unnamed: R20.2, U3.3 (Qd)
unnamed: R21.1, U3.15 (Qa)
unnamed: R21.2, U2.25 (A3)
unnamed: R22.1, U2.12 (C3)
unnamed: R22.2, U3.2 (Qc)
unnamed: R23.1, U3.1 (Qb)
unnamed: R23.2, U2.24 (B3)
unnamed: R24.1, U2.13 (DP3)
unnamed: R24.2, U3.7 (Qh)
unnamed: R25.1, U2.14 (E4)
unnamed: R25.2, U1.4 (Qe)
unnamed: R26.1, U2.15 (D4)
unnamed: R26.2, U1.3 (Qd)
unnamed: R27.1, U1.5 (Qf)
unnamed: R27.2, U2.21 (F4)
unnamed: R28.1, U2.16 (G4)
unnamed: R28.2, U1.6 (Qg)
unnamed: R29.1, U1.15 (Qa)
unnamed: R29.2, U2.20 (A4)
unnamed: R30.1, U2.17 (C4)
unnamed: R30.2, U1.2 (Qc)
unnamed: R31.1, U1.1 (Qb)
unnamed: R31.2, U2.19 (B4)
unnamed: R32.1, U2.18 (DP4)
unnamed: R32.2, U1.7 (Qh)
unnamed: U1.14 (SER), U3.9 (Qh')
unnamed: U3.14 (SER), U4.9 (Qh')
unnamed: U4.14 (SER), U5.9 (Qh')

Notes on the sheet:
Digit 1
Digit 2
Digit 3
Digit 4
GND
SRCLK
CLR
Input
VCC
Notes: Use .0402 resistors The pad numbers run counter clock wise not clock wise
RCLK
Power Supply .5V-7V

Board: 2 copper layers, 53.4 x 19.7 mm, 41 parts (0 on the bottom side), 74 nets.

## KiCad design Transmitter board/Transmitter board.kicad_pcb

Parts:
BT1: Battery_Cell; PRT-11892
C1, C3, C4: 0.1uF; C_0402
C2: 2.2uF; C_0402
C5: 10uF; C_0402
D1, D2: LED; LED_1206_HandSoldering
J3, J8: Conn_01x02_Male; Pin_Header_Straight_1x02_Pitch2.54mm
J4, J6: Conn_01x03_Male; Pin_Header_Straight_1x03_Pitch2.54mm
J5: Conn_01x04_Male; Pin_Header_Straight_1x04_Pitch2.54mm
J7: Conn_01x05_Male; Pin_Header_Straight_1x05_Pitch2.54mm
R3, R4, R5: 270 ohm; R_0402
R6: 100Kohm; R_0402
R7, R8: 330ohm; R_0402
SW1: SW_Push; KMR221GLFS
U1: RFM69HCW; RFM96HCW
U2: LPC824_HVQFN33; LPC824M201JHI33Y
U3: SWD_10-pin-1.27_Conn_2x5; Pin_Header_Straight_2x05_Pitch1.27mm_SMD
U4: XC6227C331PR-G

Connections:
Buzz_1: J5.3, U2.2 (PIO0_12)
Buzz_2: J5.4, U2.1 (PIO0_13/ADC_10)
DIO0: U1.13 (DIO0), U2.11 (PIO0_27)
Display_RCLK: J7.5, U2.9 (PIO0_10/I2C0_SCL)
Display_SRCLK: J7.4, U2.8 (PIO0_11/I2C0_SDA)
Display_Serial: J7.3, U2.5 (PIO0_28/WKCLKIN)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), D2.1 (K), J3.2, J5.1, J7.1, J8.1, SW1.2, U1.3 (GND), U1.8 (GND), U2.33 (Vss/GND), U3.3 (GND), U3.5 (GND), U3.9 (GNDDetect), U4.2
LED: R7.2, U2.10 (PIO0_16)
MISO: U1.14 (MISO), U2.13 (PIO0_25/MISO)
MOSI: U1.5 (MOSI), U2.12 (PIO0_26/MOSI)
NSS: U1.7 (NSS), U2.15 (PIO0_15/SSEL)
unnamed: BT1.1 (+), J4.1
unnamed: C2.1, C3.1, J3.1, U4.1, U4.4
unnamed: C4.1, C5.1, J4.3, U4.5
unnamed: D1.2 (A), R7.1
unnamed: D2.2 (A), R8.2
unnamed: J4.2, J6.2
unnamed: R3.1, U3.2 (SWDIO/TMS)
unnamed: R4.1, U3.4 (SWDCLK/TCK)
unnamed: R5.1, U3.10 (nRESET)
SCK: U1.6 (SCK), U2.14 (PIO0_24/SCK)
Serial_Debug: J8.2, U2.4 (PIO0_4/ADC_11/TRST)
TARGET_SWCLK: R4.2, U2.6 (SWCLK/PIO0_3/TCK)
TARGET_nRESET-P0_5: C1.1, R5.2, R6.2, SW1.1, U2.3 (PIO0_5/RESET)
Target_SWDIO: R3.2, U2.7 (SWDIO/PIO0_2/TMS)

Notes on the sheet:
VIN
GND
Power Regulator
SWD Debug
RFM69 Transceiver
LPC 824
Display Interface
RCLK
SRCLK
SER
Vin
GND
Interfaces with 8 bit Seven Segment Display
Serial Out
Power Switch
Reset Button
LED
Power Toggle Jumper
Buzzer Interface
Driver Pins

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
Board: 2 copper layers, 26.4 x 37.0 mm, 25 parts (1 on the bottom side), 26 nets.

## KiCad design 32b SR break out/32b SR break out.kicad_pcb

Parts:
J1, J2, J3, J4: Conn_01x11_Male; Socket_Strip_Straight_1x11_Pitch2.54mm
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: R_Small; R_0402_NoSilk
U1: 32bitShifter; PLCC-44

Connections:
unnamed: J1.1, R1.1
unnamed: J1.2, R2.1
unnamed: J1.3, R3.1
unnamed: J1.4, R4.1
unnamed: J1.5, R5.1
unnamed: J1.6, R6.1
unnamed: J1.7, R7.1
unnamed: J1.8, R8.1
unnamed: J1.9, R9.1
unnamed: J1.10, R10.1
unnamed: J1.11, R11.1
unnamed: J2.1, U1.29 (NC)
unnamed: J2.2, R30.1
unnamed: J2.3, R28.1
unnamed: J2.4, R26.1
unnamed: J2.5, R24.1
unnamed: J2.6, R22.1
unnamed: J2.7, R20.1
unnamed: J2.8, R18.1
unnamed: J2.9, R16.1
unnamed: J2.10, R14.1
unnamed: J2.11, R12.1
unnamed: J3.1, R13.2
unnamed: J3.2, R15.2
unnamed: J3.3, R17.2
unnamed: J3.4, R19.2
unnamed: J3.5, R21.2
unnamed: J3.6, R23.2
unnamed: J3.7, R25.2
unnamed: J3.8, R27.2
unnamed: J3.9, R29.2
unnamed: J3.10, R31.2
unnamed: J3.11, R32.2
unnamed: J4.1, U1.18 (DataOut)
unnamed: J4.2, U1.19 (NC)
unnamed: J4.3, U1.20 (NC)
unnamed: J4.4, U1.21 (NC)
unnamed: J4.5, U1.22 (Clock)
unnamed: J4.6, U1.23 (GND)
unnamed: J4.7, U1.24 (Vpp)
unnamed: J4.8, U1.25 (Vdd)
unnamed: J4.9, U1.26 (LatchE)
unnamed: J4.10, U1.27 (DataIn)
unnamed: J4.11, U1.28 (OutputE)
unnamed: R1.2, U1.40 (HVout22)
unnamed: R2.2, U1.41 (HVout21)
unnamed: R3.2, U1.42 (HVout20)
unnamed: R4.2, U1.43 (HVout19)
unnamed: R5.2, U1.44 (HVout18)
unnamed: R6.2, U1.1 (HVout17)
unnamed: R7.2, U1.2 (HVout16)
unnamed: R8.2, U1.3 (HVout15)
unnamed: R9.2, U1.4 (HVout14)
unnamed: R10.2, U1.5 (HVout13)
unnamed: R11.2, U1.6 (HVout12)
unnamed: R12.2, U1.39 (HVout23)
unnamed: R13.1, U1.7 (HVout11)
unnamed: R14.2, U1.38 (HVout24)
unnamed: R15.1, U1.8 (HVout10)
unnamed: R16.2, U1.37 (Hvout25)
unnamed: R17.1, U1.9 (HVout9)
unnamed: R18.2, U1.36 (HVout26)
unnamed: R19.1, U1.10 (HVout8)
unnamed: R20.2, U1.35 (HVout27)
unnamed: R21.1, U1.11 (HVout7)
unnamed: R22.2, U1.34 (HVout28)
unnamed: R23.1, U1.12 (HVout6)
unnamed: R24.2, U1.33 (HVout29)
unnamed: R25.1, U1.13 (HVout5)
unnamed: R26.2, U1.32 (HVout30)
unnamed: R27.1, U1.14 (HVout4)
unnamed: R28.2, U1.31 (HVout31)
unnamed: R29.1, U1.15 (HVout3)
unnamed: R30.2, U1.30 (HVoutu32)
unnamed: R31.1, U1.16 (HVout2)
unnamed: R32.1, U1.17 (HVout1)

Board: 2 copper layers, 34.0 x 29.7 mm, 37 parts (4 on the bottom side), 76 nets.

## Commit log

2018-10-22 First Commit of Kicad Files
2018-10-22 Added a ReadMe with a file directory to keep things straight.
2018-11-01 inished Minimized Disc Transmitter
2018-11-01 Finished Minimized Transmitter
2018-11-01 Added some flat edges
2018-11-05 new commit.
2018-12-17 Fixed pads on RFM footprint
2018-12-20 Logic Analysises
2018-12-27 Added reset btn and removed on off switch
2018-12-27 test
2019-01-04 Done except for deciding on a power switch
2019-01-06 Added switch and finished board
2019-01-06 unsaved files
2019-01-07 Added two traces I previously forgot.
2019-01-08 Added ground Via's
2019-01-15 Added Data Sheets to Minimized Transmitter Board
2019-02-15 Added Copper planes around the Batery holder to make the pads more secure on the board.
2019-02-15 Added more of the Data sheets to the repo
2021-05-02 Pre reimage push
